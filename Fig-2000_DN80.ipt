# Autodesk Inventor part: Fig-2000_DN80
## iProperties
Created: 2011-03
Part Number: Fig-2000_DN80
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
